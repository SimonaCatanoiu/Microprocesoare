# Keil uVision project proiect.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: proiect
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: uart.c main.c uart.h utils.c utils.h gpio.c gpio.h pit.c pit.h Adc.c Adc.h ClockSettings.c ClockSettings.h Pwm.c Pwm.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
